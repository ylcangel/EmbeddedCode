# Keil uVision project printf-demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: printf-demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c global.h uart1.c spi.c oled13.c font.h oled.c
    ../../stm_projs/: STC8Axx.h time.c
